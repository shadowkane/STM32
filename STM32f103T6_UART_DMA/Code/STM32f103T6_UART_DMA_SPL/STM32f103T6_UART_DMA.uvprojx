# Keil uVision project STM32f103T6_UART_DMA.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32f103T6_UART_DMA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group src
    ./: main.c
software components: CMSIS:CORE 5.2.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
